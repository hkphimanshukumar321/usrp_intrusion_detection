options:
  parameters:
    author: Shubham Gupta, Himanshu Kumar
    comment: Real SDR receiver with spike detector and intrusion alarm (no simulation)
    copyright: '2026'
    description: USRP RX with spike detection and audio alarm for human intrusion events
    generate_options: qt_gui
    id: reciever
    output_language: python
    title: SDR Intrusion Detection - Receiver (Real Hardware)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Match TX sample rate
    value: '1920000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Must match TX center frequency
    value: '2400000000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol
    value: '10'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Matched filter roll-off
    value: '0.35'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: Hardware RX gain
    gui_hint: 0,0,1,1
    label: RX Gain
    orient: qtgui.HORIZONTAL
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: alarm_volume
  id: variable_qtgui_range
  parameters:
    comment: Alarm loudness scaling
    gui_hint: 0,1,1,1
    label: Alarm Volume
    orient: qtgui.HORIZONTAL
    start: '0.0'
    step: '0.1'
    stop: '1.0'
    value: '0.8'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    comment: Over-the-air receiver
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: '""'
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: Normalize received level
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Matched filter for QPSK
    decim: '1'
    gain: '1'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Timing recovery
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Carrier recovery for QPSK
    order: '4'
    w: '0.05'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Demod path kept for future decoding
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Magnitude for intrusion spike detection
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    comment: Detect sudden motion peaks
    look_ahead: '10'
    threshold_factor_fall: '1.2'
    threshold_factor_rise: '1.5'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    comment: Convert detector output for GUI and alarm
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Alarm volume control
    const: alarm_volume
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Downsample detector stream to audio rate
    decim: '40'
    interp: '1'
    type: fff
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 800 Hz alarm tone
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    waveform: analog.GR_COS_WAVE
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Gate tone by spike detector output
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Alarm output to PC speaker
    samp_rate: '48000'
  states: {}
- name: qtgui_time_sink_rx
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: I
    label2: Q
    name: '"RX Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_spikes
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    color2: blue
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: Spike Detection
    label2: Raw Magnitude
    name: '"Spike Detector and Magnitude"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '2'
    ylabel: Detection
    ymax: '2.0'
    ymin: '-0.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Spectrum
    name: '"RX Spectrum"'
    type: complex
    ymin: '-80'
  states: {}
- name: blocks_file_sink_rx
  id: blocks_file_sink
  parameters:
    comment: Save RX IQ for model training/analysis
    file: rx_data_real.dat
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_rx, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0, '0', blocks_file_sink_rx, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_agc_xx_0, '0', blocks_complex_to_mag_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_peak_detector_xb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_spikes, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_spikes, '1']
- [blocks_uchar_to_float_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
