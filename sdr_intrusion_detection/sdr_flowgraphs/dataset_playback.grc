options:
  parameters:
    author: SDR Team
    comment: Play back generated .dat files
    copyright: '2026'
    description: Visualizer for the Physical SDR datasets
    generate_options: qt_gui
    id: dataset_playback
    output_language: python
    title: .DAT Dataset Visualizer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: file_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Select Dataset Class
    label0: Clear
    label1: Human
    label2: Animal
    label3: Drone
    num_opts: '4'
    option0: '"../dataset/simulated/clear.dat"'
    option1: '"../dataset/simulated/human.dat"'
    option2: '"../dataset/simulated/animal.dat"'
    option3: '"../dataset/simulated/drone.dat"'
    type: string
    value: '"../dataset/simulated/human.dat"'
    widget: radio_buttons
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Reads the .dat file
    file: file_chooser
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '10'
    threshold_factor_fall: '1.10'
    threshold_factor_rise: '1.25'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Plays back at real time
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: Spike Alert Beeps
    name: '"Amplitude Fluctuations (Physical Intrusion)"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    width1: '2'
    color2: blue
    label2: Raw Magnitude
    ymax: '2'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'False'
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,2
    name: '"Micro-Doppler Waterfall Spectrum"'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 800Hz Alarm Tone
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    waveform: analog.GR_COS_WAVE
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: PC Speakers
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Downsample 1.92M -> 48k
    decim: '40'
    interp: '1'
    type: fff
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_peak_detector_xb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
