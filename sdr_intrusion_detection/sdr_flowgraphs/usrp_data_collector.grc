options:
  parameters:
    author: SDR Team
    comment: Data collection template for USRP-based Physical RF Sensing
    copyright: '2025'
    description: Hardware Flowgraph to record physical target scattering (Human, Animal, Drone)
    generate_options: qt_gui
    id: usrp_data_collector
    output_language: python
    title: Physical Sensing USRP Data Collector
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Bandwidth
    value: '1920000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: ISM Band
    value: '2400000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: TX Gain
    orient: qtgui.HORIZONTAL
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RX Gain
    orient: qtgui.HORIZONTAL
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: file_prefix
  id: variable_qtgui_entry
  parameters:
    comment: 'Example: human, clear, dog'
    gui_hint: 1,0,1,1
    label: Target Class Name
    type: string
    value: '"human"'
  states: {}
- name: record_toggle
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,1
    label: Recording
    label0: STOP
    label1: RECORDING...
    num_opts: '2'
    option0: '0'
    option1: '1'
    options: '[0, 1]'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    comment: RX receives reflections
    dev_args: '""'
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: '""'
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    comment: TX blasts Continuous Wave
    dev_args: '""'
    gain0: tx_gain
    samp_rate: samp_rate
    sd_spec0: '""'
    stream_args: '""'
    sync: pc_clock
    type: fc32
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Pulsing Continuous Wave
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Extract Magnitude for Spikes
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Outputs the ML data
    file: '"dataset/" + file_prefix + ".dat"'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Gates recording ON/OFF
    const: record_toggle
    type: complex
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    comment: Real-time alert beeper
    look_ahead: '10'
    threshold_factor_fall: '15'
    threshold_factor_rise: '10'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: red
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: Spike Beep
    name: '"Intrusion Spikes"'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '2'
    ylabel: Detection
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Observe micro-Doppler
    ctrlpanel: 'False'
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,2
    name: '"Micro-Doppler Waterfall"'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_peak_detector_xb_0, '0', qtgui_time_sink_x_1, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
